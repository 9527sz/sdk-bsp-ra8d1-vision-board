# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, ARM_MATH_CM85, NDEBUG, RT_USING_LIBC, MICROPY_PY_DISPLAY = 1, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __FPU_PRESENT, MICROPY_PY_SENSOR = 1
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: libraries\HAL_Drivers\config;rt-thread\components\drivers\wlan;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\carray;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\hal;rt-thread\components\net\sal\include\dfs_net;packages\OpenMV-v4.5.0\src\lib\libtf;packages\OpenMV-v4.5.0\src\omv\alloc;rt-thread\components\fal\inc;board\ports;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\libc\cplusplus;packages\micropython-v1.13.0\lib\libm_dbl;rt-thread\components\libc\posix\io\epoll;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\signal;packages\micropython-v1.13.0\port\modules\machine;rt-thread\components\libc\compilers\common\extension;packages\TinyUSB-v0.14.0\src;packages\OpenMV-v4.5.0\src\omv\boards\RA8;packages\OpenMV-v4.5.0;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\include;packages\micropython-v1.13.0\ports\renesas\boards\EK-RA8D1;rt-thread\components\net\lwip\lwip-2.0.3\src\include;packages\OpenMV-v4.5.0\src\omv\modules;rt-thread\components\libc\compilers\common\extension\fcntl\octal;board\ports\wifi;rt-thread\components\finsh;rt-thread\libcpu\arm\common;packages\OpenMV-v4.5.0\src\omv\ports\ra8;packages\OpenMV-v4.5.0\src\omv\imlib;packages\TinyUSB-v0.14.0\rt-thread;board\ports\mipi_lcd;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy;rt-thread\components\net\sal\include;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\socket\sys_socket;packages\OpenMV-v4.5.0\src\omv;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\optimize;packages\micropython-v1.13.0\ports\renesas;.;packages\micropython-v1.13.0;packages\i2c-tools-v1.0.0;rt-thread\libcpu\arm\cortex-m85;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\OpenMV-v4.5.0\src\hal\cmsis\include;board\ports\omv_fs;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\eventfd;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code;packages\CmBacktrace-v1.4.1;rt-thread\components\drivers\spi;packages\rw007-v2.1.0\inc;rt-thread\components\net\netdev\include;rt-thread\components\drivers\include;rt-thread\components\net\lwip\port;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\ndarray;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\fft;packages\i2c-tools-v1.0.0\src;rt-thread\components\net\sal\include\socket;packages\rw007-v2.1.0;rt-thread\components\drivers\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\libc\posix\io\poll;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\linalg;packages\OpenMV-v4.5.0\src\omv\sensors;packages\micropython-v1.13.0\py;packages\micropython-v1.13.0\lib\utils;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\net\sal\impl;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\linalg;rt-thread\components\drivers\include;packages\micropython-v1.13.0\port\modules;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;libraries\HAL_Drivers;packages\OpenMV-v4.5.0\src\omv\common;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\utils;board;board\ports\scc8660;packages\micropython-v1.13.0\port;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\special;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\user
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cmb_port.c cmb_flash_log.c cm_backtrace.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/ports/wifi/: drv_rw007.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_flash.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_sdhi.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_partition.c fal_rtt.c fal_flash.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group i2c-tools
    packages/i2c-tools-v1.0.0/src/: i2c_tools.cpp i2c_utils.cpp
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group micropython
    packages/micropython-v1.13.0/extmod/: modwebsocket.c machine_mem.c machine_pinbase.c modframebuf.c modussl_axtls.c modujson.c vfs.c uos_dupterm.c modutimeq.c vfs_fat.c moducryptolib.c vfs_posix_file.c machine_signal.c moduzlib.c moductypes.c moduwebsocket.c moduhashlib.c modwebrepl.c machine_i2c.c utime_mphal.c modure.c modurandom.c virtpin.c machine_spi.c modubinascii.c vfs_reader.c moduselect.c vfs_fat_file.c modonewire.c modbtree.c vfs_posix.c moduheapq.c modussl_mbedtls.c vfs_fat_diskio.c machine_pulse.c
    packages/micropython-v1.13.0/lib/utils/: printf.c pyexec.c stdout_helpers.c mpirq.c sys_stdio_mphal.c interrupt_char.c
    packages/micropython-v1.13.0/py/: moduerrno.c objslice.c nlrxtensa.c objgenerator.c modcmath.c parsenum.c objdict.c nlraarch64.c pystack.c persistentcode.c scheduler.c malloc.c profile.c nlrsetjmp.c emitnxtensawin.c objgetitemiter.c objfun.c reader.c gc.c objpolyiter.c obj.c stream.c modio.c objnamedtuple.c nlrpowerpc.c opmethods.c emitcommon.c asmx86.c scope.c runtime_utils.c emitnative.c vstr.c modsys.c qstr.c objrange.c asmx64.c binary.c smallint.c modthread.c objnone.c mpz.c objproperty.c objexcept.c emitnx86.c objsingleton.c objenumerate.c builtinimport.c objdeque.c warning.c emitnarm.c objclosure.c objint_longlong.c parsenumbase.c asmbase.c sequence.c emitbc.c objint_mpz.c mpstate.c objstr.c nlr.c argcheck.c bc.c objcomplex.c formatfloat.c objint.c modgc.c mpprint.c unicode.c nlrmips.c objset.c emitinlinextensa.c asmxtensa.c objmap.c omvdummy.c builtinhelp.c objbool.c compile.c map.c parse.c nlrx64.c objmodule.c objarray.c objstrunicode.c modcollections.c objobject.c emitinlinethumb.c stackctrl.c repl.c ringbuf.c modarray.c objtype.c objlist.c modbuiltins.c objzip.c modstruct.c nlrx86.c asmthumb.c objboundmeth.c showbc.c vm.c lexer.c emitnx64.c objfilter.c objcell.c runtime.c pairheap.c nlrthumb.c emitglue.c objfloat.c objreversed.c modmath.c asmarm.c modmicropython.c frozenmod.c builtinevex.c objattrtuple.c objstringio.c nativeglue.c objtuple.c emitnxtensa.c emitnthumb.c
    packages/micropython-v1.13.0/port/: gccollect.c mpputsnport.c frozen_mpy.c mpthreadport.c mpy_main.c mpgetcharport.c mphalport.c
    packages/micropython-v1.13.0/drivers/bus/: softspi.c softqspi.c
    packages/micropython-v1.13.0/port/modules/: modpyb.c modrtthread.c modutime.c moduos.c modffi.c modutils.c modnetwork.c modusocket.c moduos_file.c modnetwork_wlan.c modfile.c
    packages/micropython-v1.13.0/port/native/: native_module.c easyflash_module.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
  group micropython/machine
    packages/micropython-v1.13.0/port/modules/machine/: machine_uart.c machine_pwm.c machine_wdt.c machine_hw_spi.c machine_pin.c machine_adc.c machine_rtc.c machine_lcd.c modmachine.c machine_timer.c machine_hw_i2c.c
  group micropython/omv-port
    packages/micropython-v1.13.0/ports/renesas/: led.c bufhelper.c pyb_uart.c machine_led.c tinyusb_debug.c pyb_i2c.c
  group openmv/alloc
    packages/OpenMV-v4.5.0/src/omv/alloc/: xalloc.c dma_alloc.c umm_malloc.c unaligned_memcpy.c fb_alloc.c
  group openmv/common
    packages/OpenMV-v4.5.0/src/omv/common/: sensor_utils.c usbdbg.c array.c mutex.c factoryreset.c vospi.c ringbuf.c trace.c
  group openmv/dsp
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/FastMathFunctions/: arm_cos_q15.c arm_sin_f32.c arm_sqrt_q15.c arm_sin_q31.c arm_cos_f32.c arm_sin_q15.c arm_sqrt_q31.c arm_cos_q31.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/TransformFunctions/: arm_rfft_init_q31.c arm_rfft_init_q15.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
  group openmv/imlib
    packages/OpenMV-v4.5.0/src/omv/imlib/: gif.c bmp.c template.c xyz_tab.c rectangle.c stats.c framebuffer.c clahe.c selective_search.c integral.c filter.c line.c eye.c isp.c lab_tab.c collections.c ppm.c mjpeg.c haar.c integral_mw.c zbar.c fsort.c edge.c lodepng.c lsd.c dmtx.c phasecorrelation.c lbp.c fast.c fft.c point.c binary.c fmath.c imlib.c hog.c blob.c orb.c rainbow_tab.c draw.c sincos_tab.c kmeans.c font.c pool.c stereo.c mathop.c yuv.c jpeg.c qsort.c qrcode.c agast.c apriltag.c jpegd.c png.c bayer.c hough.c
  group openmv/modules
    packages/OpenMV-v4.5.0/src/omv/modules/: py_gif.c py_display.c py_mjpeg.c py_helper.c py_sensor.c py_imageio.c py_image.c py_spi_display.c py_clock.c py_omv.c
  group openmv/port/ra8
    packages/OpenMV-v4.5.0/src/omv/ports/ra8/: omv_gpio.c sensor.c omv_lcd.c cambus.c
  group openmv/rtt-port
    board/ports/omv_fs/: ff_wrapper.c
  group openmv/sensor
    packages/OpenMV-v4.5.0/src/omv/sensors/: ov2640.c lepton.c paj6100.c ov5640.c mt9m114.c frogeye2020.c ov7690.c hm01b0.c gc0328.c scc8660.c ov9650.c gc2145.c ov7725.c mt9v0xx.c ov7670.c hm0360.c
  group openmv/ulab
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/linalg/: linalg.c linalg_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/: approx.c compare.c transform.c numerical.c numpy.c poly.c stats.c create.c vector.c filter.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/carray/: carray_tools.c carray.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/: ulab_tools.c ndarray_operators.c ndarray.c ulab.c ndarray_properties.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/utils/: utils.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/fft/: fft.c fft_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/ndarray/: ndarray_iter.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/user/: user.c
  group openmv/ulab/scipy
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/signal/: signal.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/optimize/: optimize.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/: scipy.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/special/: special.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/linalg/: linalg.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group TinyUSB
    packages/TinyUSB-v0.14.0/src/class/cdc/: cdc_device.c
    packages/TinyUSB-v0.14.0/src/device/: usbd.c usbd_control.c
    packages/TinyUSB-v0.14.0/rt-thread/: usb_descriptor.c tinyusb_port.c
    packages/TinyUSB-v0.14.0/src/portable/renesas/rusb2/: dcd_rusb2.c rusb2_common.c hcd_rusb2.c
    packages/TinyUSB-v0.14.0/src/: tusb.c
    packages/TinyUSB-v0.14.0/rt-thread/bsp/renesas/: drv_tinyusb.c
    packages/TinyUSB-v0.14.0/src/common/: tusb_fifo.c
  group WICED
    board/ports/scc8660/: scc8660.lib
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
