# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread\components\finsh;rt-thread\components\libc\posix\io\eventfd;board\ports;rt-thread\components\drivers\include;board;packages\i2c-tools-latest\src;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\include;rt-thread\components\drivers\include;libraries\HAL_Drivers\config;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\posix\io\poll;packages\i2c-tools-latest;rt-thread\components\libc\cplusplus;libraries\HAL_Drivers;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m85;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board\ports\mipi_lcd;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;.\packages\MLX90640\functions;.\packages\MLX90640\headers
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group i2c-tools
    packages/i2c-tools-latest/src/: i2c_tools.cpp i2c_utils.cpp
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group MLX90640
    ./packages/MLX90640/headers/: MLX90640_I2C_Driver.h MLX90640_API.h
    ./packages/MLX90640/functions/: MLX90640_API.c
    ./: MLX90640_DISPLAY.c MLX90640_DISPLAY.h font.h
software components: Flex Software:RA Configuration 1.0.0
